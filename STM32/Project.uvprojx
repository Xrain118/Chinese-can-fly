# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,HSE_VALUE=8000000
  c misc: --no-multibyte-chars
  c include: .\Start\F4;.\Start\CMSIS;.\User;.\System;.\Hardware;.\App;.\Middlewares\FreeRTOS-Kernel\include;.\Middlewares\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/F4/: startup_stm32f407xx.s system_stm32f4xx.c system_stm32f4xx.h stm32f4xx.h stm32f407xx.h
    ./Start/CMSIS/: core_cm4.h
  group System
    ./System/: BoardClock.c BoardClock.h SystemTick.c SystemTick.h Delay.c Delay.h FreeRTOSConfig.h FreeRTOSHooks.c
  group Hardware
    ./Hardware/: BoardPins.h MotorPWM.c MotorPWM.h Motor.c Motor.h Encoder.c Encoder.h Serial.c Serial.h PowerMonitor.c PowerMonitor.h
  group App
    ./App/: SimplePID.c SimplePID.h DriveControl.c DriveControl.h DebugProtocol.c DebugProtocol.h Safety.c Safety.h ProtocolTx.c ProtocolTx.h UgvCommand.h UgvCommandQueue.c UgvCommandQueue.h UgvTasks.c UgvTasks.h
  group FreeRTOS
    ./Middlewares/FreeRTOS-Kernel/: tasks.c queue.c list.c
    ./Middlewares/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
  group User
    ./User/: main.c stm32f4xx_it.c stm32f4xx_it.h
